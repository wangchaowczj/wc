# Keil uVision project App.uvproj, settings and files
target App (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CPU +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Driver\src;..\User;..\uCOS-II\Ports;..\uCOS-II\Source;..\FatFs\src
  memory RVCT4: ROM 0x800c800 size 0x32800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Main
    ../User/: Main.c
  group User
    ../User/: stm32f10x_it.c SystemConfig.c Recorder.c Task.c TaskUtils.c DetTest.c Uart1Respond.c Uart3Respond.c
  group Driver
    ../User/: Delay.c CRC16.c ADC.c DetHardware.c Led.c Uart.c Package.c aes.c slip.c CRC8.c CRC32.c WatchDog.c XA3_DetCmd.c SPI.c SdCard.c
  group uCOS-II\Ports
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c app_cfg.h
  group uCOS-II\Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.c
  group CMSIS
    ../CMSIS/: startup_stm32f10x_hd.s system_stm32f10x.c core_cm3.c
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_spi.c
  group Fatfs
    ../FatFs/src/: diskio.c ff.c
  group Doc
    ../Doc/: History.txt
