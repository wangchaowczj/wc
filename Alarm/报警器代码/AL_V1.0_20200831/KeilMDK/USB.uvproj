# Keil uVision project USB.uvproj, settings and files
target ALARM (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ALARM +hex
  c flags: Optim=1 oTime=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CH374;..\CMSIS;..\STM32F10x_StdPeriph_Driver\inc;..\uCOS-II\Ports;..\uCOS-II\Source;..\USER
  memory RVCT4: ROM 0x800c800 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group USER
    ../USER/: Task.c stm32f10x_it.c SystemConfig.c GuestRespond.c MidFunction.c Recorder.c Watchdog.c main.c
  group DRIVER
    ../USER/: Adc.c Aes.c CRC16.c Delay.c I2c.c LcdUtils.c Lcd.c Led.c Package.c Slip.c
  group CH374
    ../CH374/: CH374Device.c CH374DeviceHid.c CH374Interface.c
  group FWLIB
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_rtc.c
  group UCOSII-PORT
    ../uCOS-II/Ports/: os_dbg.c os_cpu_c.c os_cpu_a.asm
  group UCOSII-SOURCE
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.c
  group DOC
    ../doc/: readme.txt
