# Keil uVision project BootLoader.uvproj, settings and files
target BootLoader (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BootLoader +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Driver\src;..\User;..\CH374
  memory RVCT4: ROM 0x8000000 size 0xc800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Main
    ../User/: Main.c
  group User
    ../User/: SystemConfig.c stm32f10x_it.c CRC16.c Delay.c slip.c AppUpdate.c aes.c Package.c Led.c UsbRespond.c
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_exti.c
  group CMSIS
    ../CMSIS/: system_stm32f10x.c core_cm3.c startup_stm32f10x_hd.s
  group CH374
    ../CH374/: CH374Device.c CH374DeviceHid.c CH374Interface.c CH374Process.c
  group Doc
    ../Doc/: History.txt
